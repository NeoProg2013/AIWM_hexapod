# IAR project MainMCU.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F373RC ST STM32F373RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F373xC
  ICCARM.CCIncludePath2: src; CMSIS\Include; CMSIS\STM32F3xx; src\drivers; src\tools; src\motion-core
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: MainMCU.hex
  prebuild: pre-build\pre-build.bat
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: src\stm32f372xC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  group CMSIS/Include
    CMSIS/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h tz_context.h
  group CMSIS/STM32F3xx
    CMSIS/STM32F3xx/: startup_stm32f373xc.s stm32f373xc.h stm32f3xx.h system_stm32f3xx.c system_stm32f3xx.h
  group src
    src/: cli.c cli.h configurator.c configurator.h display.c display.h gait_sequences.h indication.c indication.h main.c memory-map.h project-base.h sensors-core.c sensors-core.h servo-driver.c servo-driver.h swlp-protocol.h smcu.c smcu.h swlp.c swlp.h system-monitor.c system-monitor.h version.h
  group src/drivers
    src/drivers/: adc.c adc.h i2c1.c i2c1.h i2c2.c i2c2.h mpu6050.c mpu6050.h pca9555.c pca9555.h pwm.c pwm.h ssd1306-128x64.c ssd1306-128x64.h systimer.c systimer.h usart1.c usart1.h usart2.c usart2.h
  group src/motion-core
    src/motion-core/: math-structs.h motion-core.c motion-core.h motion-math.c motion-math.h
  group src/tools
    src/tools/: oled-gl-font-6x8.h oled-gl.c oled-gl.h
