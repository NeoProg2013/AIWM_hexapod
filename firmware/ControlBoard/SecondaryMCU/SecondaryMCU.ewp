# IAR project SecondaryMCU.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030F4 ST STM32F030F4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: STM32F030
  ICCARM.CCIncludePath2: src; CMSIS; src\drivers; src\tools
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SecondaryMCU.hex
  ILINK.IlinkOutputFile: SecondaryMCU.out
  ILINK.IlinkIcfFile: src\stm32f030x4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h core_sc000.h core_sc300.h startup_stm32f030.s stm32f0xx.h
  group src
    src/: main.c project_base.h stm32f030x4.icf
  group src/drivers
    src/drivers/: hx711.c hx711.h i2c1.c i2c1.h mpu6050.c mpu6050.h systimer.c systimer.h usart1.c usart1.h
